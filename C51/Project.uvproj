# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Inc
  group Src
    ./: Conf_tny.A51
    ../Src/: cp.c key.c led.c main.c uart.c eeprom.c
